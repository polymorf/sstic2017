## linux-openrisc/drivers/misc/sstic/Kconfig
```kconfig
config SSTIC
    tristate "SSTIC Challenge driver"
    depends on OPENRISC
    ---help---
      Enable Linux Kernel SSTIC driver
```
